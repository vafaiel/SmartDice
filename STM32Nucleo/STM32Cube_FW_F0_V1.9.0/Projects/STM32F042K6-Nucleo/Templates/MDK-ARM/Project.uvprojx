# Keil uVision project Project.uvprojx, settings and files
target STM32F042K6_NUCLEO (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F042K6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x200017FF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: STM32F042K6_NUCLEO
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F042x6,USE_STM32F0XX_NUCLEO_32,USE_HAL_DRIVER
  c misc: --C99
  c include: ../Inc;../../../../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../../../../Drivers/STM32F0xx_HAL_Driver/Inc;../../../../Drivers/BSP/STM32F0xx_Nucleo_32
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  link misc: --diag_suppress=L6329
  group Drivers/BSP/STM32F0xx_Nucleo_32
    ../../../../Drivers/BSP/STM32F0xx_Nucleo_32/: stm32f0xx_nucleo_32.c
  group Example/MDK-ARM
    ./: startup_stm32f042x6.s
  group Example/User
    ../Src/: stm32f0xx_it.c stm32f0xx_hal_msp.c main.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Doc
    ../: readme.txt
  group Drivers/STM32F0xx_HAL_Driver
    ../../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_flash_ex.c stm32f0xx_hal_cec.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_wwdg.c stm32f0xx_hal_adc.c stm32f0xx_hal_pcd.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_smartcard_ex.c stm32f0xx_hal_crc.c stm32f0xx_hal_iwdg.c stm32f0xx_hal_smartcard.c stm32f0xx_hal_tim.c stm32f0xx_hal_dac.c stm32f0xx_hal_smbus.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_irda.c stm32f0xx_hal_crc_ex.c stm32f0xx_hal_rtc.c stm32f0xx_hal_spi.c stm32f0xx_hal_i2c.c stm32f0xx_hal_usart.c stm32f0xx_hal_dma.c stm32f0xx_hal_can.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_tsc.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_flash.c stm32f0xx_hal.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_i2s.c stm32f0xx_hal_dac_ex.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_comp.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_uart.c
software components: CMSIS:CORE 4.3.0
